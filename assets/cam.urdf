Commit message: cleanup

File: assets/cam.urdf (robot description, URDF)
Before this commit: robot camera_robot, 3 links, 2 joints
Joints:
- joint camera_joint: origin xyz=0 0 .1 rpy=0 0.3490658503988659 0 -> xyz=0 0 .2 rpy=0 0.3490658503988659 0
